Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SKY LUM-P 50.1240.5105.IFC
Time: 2023-11-03T08:32:32
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: SKY LUM-P 50.1240.5105
In: Default Storey
SolidWorks Custom Properties - Description: PWR(50W);LUM.FLUX(5105lm)
PSet_Mass_Property - Mass Measure: 11.068; Area Measure: 0; Volume Measure: 0.011068 m3
